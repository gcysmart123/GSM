# Keil uVision project GPRS_51_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: GPRS_51_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 GPRS.C
    ./code/: GSM.H 1602.h 12864.h ds18b20.h ds1302.h GPRS_GTM900C.H GPRS_SIM300.h
