# Keil uVision project Object.uvproj, settings and files
target 工程 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: object +hex
  c flags: Optim=1 OneElfS=1
  c include: .\Init;.\App;.\CPU_LIB;..\二代控制器程序V2.0.100226
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: STM32F10x.s cortexm3_macro.s
  group CPU_Lib
    ./CPU_LIB/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_nvic.c
  group App
    ./App/: main.c
